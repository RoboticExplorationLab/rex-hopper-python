Commit message: Adjusted mass of robot torso

File: res/flyhopper_robot/urdf/flyhopper_robot.urdf (robot description, URDF)
Before this commit: robot flyhopper_robot, 5 links, 4 joints
Links:
- link base_link: mass 10 -> 7
